## config/boards/shields/my_6x5/Kconfig.defconfig
```kconfig
# Copyright (c) 2025
# SPDX-License-Identifier: MIT

config SHIELD_MY_6X5
    bool "my_6x5"
```
